# Keil uVision project Firmware_dist_calculation_simple.uvprojx, settings and files
target Firmware_dist_calculation_simple (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G041K8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: Firmware_dist_calculation_simple +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32G041xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g041xx.s
  group Application/User/Core
    ../Core/Src/: config_periph.c i2c_functions.c pll_functions.c capture_configure.c main.c stm32g0xx_it.c analyse.c delay_us_timer.c measure_functions.c distance_calc.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_ll_utils.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c stm32g0xx_ll_i2c.c stm32g0xx_ll_pwr.c stm32g0xx_ll_tim.c stm32g0xx_ll_usart.c stm32g0xx_ll_flash.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group inc
    ../Core/Inc/: config_periph.h main.h stm32g0xx_it.h i2c_functions.h pll_functions.h analyse.h
software components: CMSIS:CORE 5.0.1
