# IAR project Project.ewp, settings and files
configuration STM32F030 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030x6 ST STM32F030x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F030; USE_DEFAULT_TIMEOUT_CALLBACK
  ICCARM.CCIncludePath2: ..\; ..\StdPeriphLib; ..\StdPeriphLib\inc; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32F0XX_LD.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f030F4P6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../: startup_stm32f0xx.s system_stm32f0xx.c
  group StdPeriph_Driver
    ../StdPeriphLib/src/: stm32f0xx_adc.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group User
    ../: analyse.c capture_configure.c config_periph.c delay_us_timer.c distance_calc.c i2c_functions.c main.c measure_functions.c pll_functions.c stm32f0xx_it.c uart_handler.c
